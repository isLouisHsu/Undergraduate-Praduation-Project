# IAR project Debug.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; ..\..\Hardware\Steering; ..\..\Hardware\Motor; ..\..\Hardware\Camera; ..\..\Hardware\LedKey; ..\..\Hardware\Control; ..\..\Hardware\Encoder; ..\..\Hardware\Bluetooth; ..\..\Hardware\Serialport; ..\..\Hardware\Oled; ..\..\Hardware\Dt; ..\..\Hardware\Uart; ..\..\Hardware\Pit; ..\..\Hardware\Flash
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Debug.hex
  ILINK.IlinkOutputFile: Debug.out
  ILINK.IlinkIcfFile: config files\fire_ROM_K60N512.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Hardware\Bluetooth; ..\..\Hardware\Camera; ..\..\Hardware\Control; ..\..\Hardware\DT; ..\..\Hardware\Encoder; ..\..\Hardware\LedKey; ..\..\Hardware\Motor; ..\..\Hardware\Oled; ..\..\Hardware\Serialport; ..\..\Hardware\Steering; ..\..\Hardware\Uart
  OBJCOPY.OOCOutputFile: Debug.srec
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM41_math.a
  group APP
    ../../APP/: FIRE_MK60_conf.c main.c
    ../../APP/inc/: FIRE_MK60_conf.h FIRE_PORT_cfg.h MK60_it.h
  group Board
    ../../Board/src/: FIRE_key.c FIRE_LED.C
  group Chip
    ../../Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
    ../../Hardware/Uart/: uart_comm.c
  group Hardware
    ../../Hardware/Bluetooth/: bluetooth.c
    ../../Hardware/Control/: control.c
    ../../Hardware/Dt/: datatranslate.c
    ../../Hardware/Camera/: eaglecamera.c imageprocessing.c predatorcamera.c VCAN_camera.c VCAN_camera.h VCAN_computer.c VCAN_computer.h VCAN_OV7725_Eagle.c VCAN_OV7725_Eagle.h VCAN_OV7725_REG.h VCAN_SCCB.c VCAN_SCCB.h
    ../../Hardware/Encoder/: encoder.c
    ../../Hardware/Flash/: Flash.c
    ../../Hardware/LedKey/: LedKey.c
    ../../Hardware/Motor/: motor.c
    ../../Hardware/Oled/: oled.c
    ../../Hardware/Pit/: PIT.c
    ../../Hardware/Serialport/: serialport.c
    ../../Hardware/Steering/: steering.c
