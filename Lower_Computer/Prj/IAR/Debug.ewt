<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\..\..\APP\FIRE_MK60_conf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\APP\inc\FIRE_MK60_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\APP\inc\FIRE_PORT_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\APP\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\APP\inc\MK60_it.h</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\FIRE_key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Board\src\FIRE_LED.C</name>
    </file>
  </group>
  <group>
    <name>Chip</name>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_DWT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_ftm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_SysTick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\MK60_wdog.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\IAR\startup_MK60DZ10.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\IAR\system_MK60DZ10.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Uart\uart_comm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\src\vectors.c</name>
    </file>
  </group>
  <group>
    <name>Hardware</name>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Bluetooth\bluetooth.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Control\control.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Dt\datatranslate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\eaglecamera.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Encoder\encoder.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Flash\Flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\imageprocessing.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\LedKey\LedKey.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Motor\motor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Oled\oled.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Pit\PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\predatorcamera.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Serialport\serialport.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Steering\steering.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\VCAN_camera.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\VCAN_camera.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\VCAN_computer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\VCAN_computer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\VCAN_OV7725_Eagle.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\VCAN_OV7725_Eagle.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\VCAN_OV7725_REG.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\VCAN_SCCB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Hardware\Camera\VCAN_SCCB.h</name>
    </file>
  </group>
  <group>
    <name>Lib</name>
  </group>
</project>


